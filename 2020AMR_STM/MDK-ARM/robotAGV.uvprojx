# Keil uVision project robotAGV.uvprojx, settings and files
target App-TD-EJ-CTRL (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bin +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\Deal;..\Driver;..\myLib;..\mycanopen;..\Misc;..\robotType
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_can.c
  group main
    ../: system_stm32f4xx.c main.c stm32f4xx_it.c
    ../STM32F4xx_StdPeriph_Driver/: arm_cortexM4lf_math.lib
  group myLib
    ../myLib/: LinerBuf.c ringbuf.c
  group MiscDev
    ../Misc/: timerDev.c
  group mycanopen
    ../mycanopen/: CAN_Stm32f4xx.c mycanopen.c dealMotec.c configMotec.c
  group Device
    ../Driver/: LiBattery.c rearRadar.c ROSDev.c HMIDev.c statusLamp.c Button.c AheadRadar.c
  group Deal
    ../Deal/: baseRobot.c
  group robotType
    ../robotType/: diffRobot2.c
target Boot-TD-EJ-CTRL (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: as above
  output: bin
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output "./bin/EJ-Ctrl.bin" "./bin/bin.axf"
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000,PROG_BOOT,VECT_TAB_OFFSET=0
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\sdio;..\fatfs;..\Decode;..\Deal;..\Driver;..\Ethernet;..\Lwip;..\NAND
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
